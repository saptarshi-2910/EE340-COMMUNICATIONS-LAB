options:
  parameters:
    author: sappylappy
    generate_options: qt_gui
    id: TASK4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.9'
  states: {}
- name: 'off'
  id: variable_qtgui_range
  parameters:
    label: 'off'
    start: '0'
    step: '0.1'
    stop: '10'
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: skip_head
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[0-0j, 0+1j, 1+1j, 1-0j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: '8000000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: 8000000 + off
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: '8000000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500000'
    offset: '0'
    phase: '0'
    samp_rate: 8000000 + off
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '100'
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: output4.txt
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/sappylappy/Desktop/DESKTOP/EE340/Lab_8/Original_Text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.414'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.414'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '11'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.001'
    init: '0'
    low: '-0.001'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.001'
    init: '0'
    low: '-0.001'
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '-0.0000001'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '-0.0000001'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: '50000'
    sensitivity: '-5'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1-1j, -1+1j, 1+1j, 1-1j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '1'
    type: ccc
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,1]'
    fftaps: '[1.0001,-1]'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,0.99]'
    fftaps: '0.01'
    type: ffd
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Before Modulation"'
    size: '1024'
    srate: '80000'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"After Modulation"'
    size: '1024'
    srate: '80000'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '20'
    type: ccf
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '3'
    ntaps: 11*sps
    samp_rate: sps*symbol_rate
    sym_rate: '50000'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '3'
    ntaps: 11*sps
    samp_rate: sps*symbol_rate
    sym_rate: '50000'
    type: fir_filter_ccf
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: float
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:50001
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_1_0_0, '1']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_1_0, '0']
- [analog_sig_source_x_0_0_1_0, '0', blocks_multiply_xx_0_1_0_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0_1_0_0, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0_1_0_1, '1']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_float_0, '1', blocks_threshold_ff_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_threshold_ff_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_threshold_ff_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '0', blocks_multiply_xx_0_1_0, '1']
- [blocks_complex_to_float_0_0_0, '1', blocks_multiply_xx_0_1, '0']
- [blocks_delay_0, '0', iir_filter_xxx_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_float_to_complex_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', zeromq_push_sink_0, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_delay_0, '0']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_xx_0_1_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0_1_0_1, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_const_sink_x_1, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_file_sink_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_sub_xx_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_complex_1, '1']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_complex_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_skiphead_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_float_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_multiply_xx_1, '1']
- [iir_filter_xxx_0, '0', blocks_vco_c_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_complex_to_float_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', fir_filter_xxx_0, '0']
- [zeromq_pull_source_0, '0', blocks_multiply_const_vxx_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
