options:
  parameters:
    generate_options: qt_gui
    id: task3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: gain_band_1_range
  id: variable_qtgui_range
  parameters:
    label: Gain Band 1
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: gain_band_2_range
  id: variable_qtgui_range
  parameters:
    label: Gain Band 2
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: gain_band_3_range
  id: variable_qtgui_range
  parameters:
    label: Gain Band 3
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: gain_band_4_range
  id: variable_qtgui_range
  parameters:
    label: Gain Band 4
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: gain_band_5_range
  id: variable_qtgui_range
  parameters:
    label: Gain Band 5
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    gain: '1'
    high_cutoff_freq: '500'
    interp: '1'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_KAISER
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    beta: '6.76'
    gain: '1'
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '500'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '500'
    win: window.WIN_KAISER
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    beta: '6.76'
    gain: '1'
    high_cutoff_freq: '6000'
    interp: '1'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '500'
    win: window.WIN_KAISER
  states: {}
- name: band_pass_filter_2_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    gain: '1'
    high_cutoff_freq: '15000'
    interp: '1'
    low_cutoff_freq: '9000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_KAISER
  states: {}
- name: band_pass_filter_2_1
  id: band_pass_filter
  parameters:
    beta: '6.76'
    gain: '1'
    high_cutoff_freq: '9000'
    interp: '1'
    low_cutoff_freq: '6000'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '500'
    win: window.WIN_KAISER
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_band_1_range
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_band_5_range
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_band_4_range
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_band_2_range
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_band_3_range
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_3
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample4: FORMAT_PCM_16
    file: /home/saptarshi-biswas/Desktop/DESKTOP/EE340/LAB_1/equalizer.wav
    format: FORMAT_RF64
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/saptarshi-biswas/Desktop/DESKTOP/EE340/LAB_1/Bach.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/saptarshi-biswas/Desktop/DESKTOP/EE340/LAB_1/Bach.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    file: /home/saptarshi-biswas/Desktop/DESKTOP/EE340/LAB_1/Bach.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_2
  id: blocks_wavfile_source
  parameters:
    file: /home/saptarshi-biswas/Desktop/DESKTOP/EE340/LAB_1/Bach.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_3
  id: blocks_wavfile_source
  parameters:
    file: /home/saptarshi-biswas/Desktop/DESKTOP/EE340/LAB_1/Bach.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_1, '0', blocks_multiply_const_vxx_0_2, '0']
- [band_pass_filter_2, '0', blocks_multiply_const_vxx_0_3, '0']
- [band_pass_filter_2_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [band_pass_filter_2_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_3, '0', blocks_add_xx_0, '2']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0_0, '0', band_pass_filter_1, '0']
- [blocks_throttle2_0_1, '0', band_pass_filter_2, '0']
- [blocks_throttle2_0_2, '0', band_pass_filter_2_1, '0']
- [blocks_throttle2_0_3, '0', band_pass_filter_2_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_throttle2_0_3, '0']
- [blocks_wavfile_source_0_1, '0', blocks_throttle2_0_2, '0']
- [blocks_wavfile_source_0_2, '0', blocks_throttle2_0_0, '0']
- [blocks_wavfile_source_0_3, '0', blocks_throttle2_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
