options:
  parameters:
    generate_options: qt_gui
    id: Task1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: m
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: quadrature_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: m
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '50'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_rate
    type: float
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: quadrature_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/saptarshi29/Desktop/DESKTOP/EE340/Lab 2 Resources-20240820/vocal.wav
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: freq
  id: qtgui_tab_widget
  parameters:
    label0: Message
    label1: Modulated
    label2: Demodulated
    num_tabs: '3'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '11000'
    gain: '1'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: freq@0
    name: '"Message"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quadrature_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: freq@1
    name: '"Modulated"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: freq@2
    name: '"Message"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@2
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    name: '"Message"'
    size: '1024'
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    name: '"Modulated"'
    size: '1024'
    srate: quadrature_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: '960000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '960000'
    interp: '32000'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Message
    label1: Modulated
    label2: Demodulated
    num_tabs: '3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_1_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', dc_blocker_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_1_0_0_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_1, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle2_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
